Properties of the parts of a building model (IFC4), part 2 of 3

# IfcCovering: Basic Wall:REVIGRES-LIMESTONE-BASE-88,9x88,9-RECT-SAND, Basic Wall:REVIGRES-LIMESTONE-BASE-88,9x88,9-RECT-SAND:123192
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 13500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: C; ResistenciaAoEscorregamentoENV51097: C; ResistenciaAoEscorregamentoENV12633: Class 3; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 3; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 4; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 20 mm; ComprimentoNominal: 90 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-LIMESTONE-BASE-88,9x88,9-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST:123308
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-ANTISLIPRECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 302DX35V21; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST_TECH20, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST_TECH20:123374
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-ANTISLIPRECT-MIST-TECH20
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST_TECH20
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST_TECH20
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 312DX32Q41; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 4; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 20 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-MIST-TECH20; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND:123300
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-ANTISLIPRECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 302DX35V31; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND_TECH20, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND_TECH20:123367
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-ANTISLIPRECT-SAND-TECH20
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND_TECH20
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND_TECH20
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 312DX32Q31; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 4; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 20 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-ANTISLIPRECT-SAND-TECH20; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-MIST:123255
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-RECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121K75V21; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-SAND:123263
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x120-RECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3021X35V31; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6x118,6-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-MIST:123275
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x278-RECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3021X45V21; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6X277,8-RECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-SAND:123283
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-120x278-RECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-118,6x277,8-RECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3021X45V31; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-118,6X277,8-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-MIST:123126
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-30x60-RECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121215V21; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 8.5 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-SAND:123171
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-30x60-RECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121215V31; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 8.5 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-29,5x59,2-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-MIST:123144
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-45X90-RECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121H85V21; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-SAND:123187
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-45X90-RECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121H85V31; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-44,35x88,9-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-MIST-TECH20, Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-MIST-TECH20:123335
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x120-ANTISLIPRECT-MIST-TECH20
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-MIST-TECH20
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-MIST-TECH20
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 312DD32Q41; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 13500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: C; ResistenciaAoEscorregamentoENV51097: C; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 4; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 20 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-MIST-TECH20; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-SAND-TECH20, Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-SAND-TECH20:123342
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x120-ANTISLIPRECT-SAND-TECH20
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-SAND-TECH20
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-SAND-TECH20
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 312DD32Q31; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 13500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: C; ResistenciaAoEscorregamentoENV51097: C; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 4; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 20 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-59,2x118,6-ANTISLIPRECT-SAND-TECH20; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-MIST:123162
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x120-RECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121D35V21; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-SAND, Floor:REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-SAND:123203
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x120-RECT-SAND
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-SAND
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 3121D35V31; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-59,2x118,6-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST, Floor:REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST:123225
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x60-ANTISLIPRECT-MIST
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: LIMESTONE; NumeroGlobalDeItemComercial: 312D135V31; Acabamento: ANTISLIPRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/limestone; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: ≥ 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 3; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 3; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 8.5 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST-TECH20, Floor:REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST-TECH20:123328
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-LIMESTONE-BASE-60x60-ANTISLIPRECT-MIST-TECH20
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-LIMESTONE-BASE-59,2x59,2-ANTISLIPRECT-MIST-TECH20
